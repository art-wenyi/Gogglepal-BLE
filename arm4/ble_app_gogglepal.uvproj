# Keil uVision project ble_app_gogglepal.uvproj, settings and files
target nrf51822_xxaa_s110 (256K) (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: GogglePal +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD S110 BOARD_PCA10028 BSP_UART_SUPPORT SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0
  c misc: --c99
  c include: ..\config;..\components\softdevice\s110\headers;..\components\drivers_nrf\uart;..\components\ble\common;..\components\ble\ble_services\ble_bas;..\components\libraries\sensorsim;..\components\drivers_nrf\hal;..\components\libraries\button;..\components\device;..\components\toolchain;..\components\libraries\fifo;..\components\drivers_nrf\gpiote;..\components\drivers_nrf\config;..\components\libraries\util;..\components\drivers_nrf\common;..\components\ble\device_manager;..\components\softdevice\common\softdevice_handler;..\components\libraries\timer;..\components\drivers_nrf\pstorage;..\components\libraries\trace;..;..\bsp;..\components\ble\ble_services\ble_gls;..\components\ble\ble_advertising;..\components\ble\ble_racp;..\components\ble\ble_services\ble_dis;..\components\libraries\scheduler;..\components\libraries\gpiote;..\components\ble\ble_debug_assert_handler;..\components\ble\ble_radio_notification;..\components\ble\ble_services\ble_ancs_c;..\components\ble\ble_db_discovery
  asm define: as above
  library: MicroLIB
  group Application
    ../: main.c
  group Board Support
    ../bsp/: bsp.c bsp_btn_ble.c
  group Device
    ../components/toolchain/: system_nrf51.c
    ../components/toolchain/arm/: arm_startup_nrf51.s
  group Documentation
    ../: Abstract.txt license.txt
  group nRF_BLE
    ../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../components/ble/ble_services/ble_bas/: ble_bas.c
    ../components/ble/device_manager/: device_manager_peripheral.c
    ../components/ble/ble_advertising/: ble_advertising.c
    ../components/ble/ble_services/ble_dis/: ble_dis.c
    ../: ble_gogglepal.c
    ../components/ble/ble_radio_notification/: ble_radio_notification.c
    ../components/ble/ble_services/ble_ancs_c/: ble_ancs_c.c
    ../components/ble/ble_db_discovery/: ble_db_discovery.c
  group nRF_Drivers
    ../components/drivers_nrf/uart/: app_uart_fifo.c
    ../components/drivers_nrf/hal/: nrf_delay.c
    ../components/drivers_nrf/common/: nrf_drv_common.c
    ../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../components/libraries/button/: app_button.c
    ../components/libraries/util/: app_error.c nrf_assert.c
    ../components/libraries/fifo/: app_fifo.c
    ../components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../components/libraries/trace/: app_trace.c
    ../components/libraries/uart/: retarget.c
    ../components/libraries/sensorsim/: sensorsim.c
    ../components/libraries/scheduler/: app_scheduler.c
  group nRF_SoftDevice
    ../components/softdevice/s110/doc/: s110_nrf51_8.0.0_licence-agreement.txt
    ../components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: s110_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..\..\..\config
  asm define: BLE_STACK_SUPPORT_REQD
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
